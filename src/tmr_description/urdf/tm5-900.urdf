Commit message: Update URDF to put EOAT at gripper tip

File: src/tmr_description/urdf/tm5-900.urdf (robot description, URDF)
Before this commit: robot tm5-900, 10 links, 9 joints
Joints:
- joint joint_EOAT: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.15 rpy=0 0 0
